# Repository kevinkrieger/CAN

File README.md:

Git repo for obd2-CAN board.

* obd2/ directory contains the KiCAD files
* lpcxpresso/ directory contains the files required to build firmware with lpcxpresso
* obd2_lpc1343/ is legacy directory when the 1343 was explored.
* reference/ contains CAN and obd2 and other reference material used in design
* video/ videos taken of design/build/test
* datasheets/ any datasheets of parts used or explored

## KiCad design obd2-v2/obd2.kicad_pcb

Board: 2 copper layers, 80.0 x 49.0 mm, 64 parts (11 on the bottom side), 56 nets.

Parts:
C1: 0.33uF; c_0805
C2, C4: 0.1uF; c_0805
C3: 10uF; c_0805
C5, C7, C9, C10, C13, C14, C15: 0.1u; c_0805
C6: C; c_0805
C8: C_CON; c_0805
C11, C12: 39pF; c_0805
D1, D3: 1N4149; DO-35
D2: 3V3_ON; LED_J_LEAD
F1: 300mA; SM0603
J1: RJ45_BASIC; RJ45
J2: MICRO_SD; SD_502702_003
JP1: VSEL; SOLDER_JUMPER_3
K1: UART; SIL-3
LCD1: LCD16X2; GDM1602K
MP2, MP3, MP4: SCREW_4-40; 1pin
P1: JTAG_PROG; GRPB052VWQS-RC
P2: IO_2; SIL-6
P3: IO_1; SIL-4
Q1: Q_CON; SOT523
Q2: MOSFET_N; SOT523
Q3: BT_ON; SOT523
R1: 330R; SM0805
R2, R3, R6: R; SM0805
R4, R5: 60R; SM0805
R7, R12, R14: 10k; SM0805
R8: R_CON0; SM0805
R9: R_CON1; SM0805
R10: R_CON2; SM0805
R11: R_LCD_LED; SM0805
R13: R_CON3; SM0805
SW1: PWR_SW; MMS1208
SW2: 1; FSM4JSMA_pushbutton
SW3: 2; FSM4JSMA_pushbutton
SW4: 3; FSM4JSMA_pushbutton
U1: LD1117; DPAK
U2: SP7805; TO-252-3
U3: MCP2561; SOIC-8-Narrow
U4: MC33660; SOIC-8-Narrow
U5: LTV-816; DIP_4
U6: HC05
U7: LPC11C14; LQFP48
U8: TC1047A; SOT23
W1: 12V_T; TEST_POINT_2PADS
W2: VBAT_T; TEST_POINT_2PADS
W3: 5V_T; TEST_POINT_2PADS
W4: 3V3_T; TEST_POINT_2PADS
X1: 20MHz; CSM-3X

Connections:
+3.3V: C3.1, C13.1, C14.1, C15.1, J2.4, JP1.1, P1.1, P2.2, Q3.D, R1.1, R7.1, R11.1, R12.1, R14.1, U1.2, U7.8, U7.44, U8.1, W4.1
+5V: C2.1, C4.1, C5.1, JP1.3, U1.3, U2.3, U3.3, U4.7, W3.1
+12V: C1.1, F1.1, R6.1, U2.1, U4.1, W1.1
BT_KEY: U6.34, U7.30
BT_ON: Q3.G, U7.32
BT_RESET: U6.11, U7.34
Button1: C7.1, R7.2, SW2.2, U7.33
Button2: C9.1, R12.2, SW3.2, U7.26
Button3: C10.2, R14.2, SW4.2, U7.25
CAN_H: J1.1, R4.1, U3.7
CAN_L: J1.2, R5.2, U3.6
CAN_RXD: U3.4, U7.19
CAN_TXD: U3.1, U7.20
CAN_XCVR_RS: U3.8, U7.18
CARD_DETECT: J2.12, U7.36
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.2, C8.2, C9.2, C10.1, C11.1, C12.1, C13.2, C14.2, C15.2, D2.2, D3.1, J1.3, J1.8, J2.6, J2.9, J2.10, J2.11, J2.13, J2.14, K1.3, LCD1.1, P1.3, P1.5, P1.9, P2.1, P3.4, Q1.S, Q2.S, R13.1, SW2.1, SW3.1, SW4.1, U1.1, U2.2, U3.2, U4.3, U5.2, U5.3, U6.13, U6.21, U6.22, U7.5, U7.41, U8.3, W1.2, W2.2, W3.2, W4.2
K_LINE: J1.5, U4.4
K_LINE_EN: U4.8, U7.21
K_LINE_RX: U4.6, U7.22
K_LINE_TX: U4.5, U7.23
LCD_CONT: R8.2, U7.35
LCD_DB4: LCD1.11, U7.9
LCD_DB5: LCD1.12, U7.11
LCD_DB6: LCD1.13, U7.12
LCD_DB7: LCD1.14, U7.13
LCD_LED: Q2.G, U7.17
LCD_RS: LCD1.4, U7.1
LCD_RW: LCD1.5, U7.2
L_LINE: J1.6, R6.2, U5.4
L_LINE_CONTROL: R2.1, U7.24
unnamed: D1.2, F1.2
unnamed: D1.1, SW1.1
unnamed: D2.1, R1.2
unnamed: D3.2, R2.2, U5.1
unnamed: C6.2, R3.2, R4.2, R5.1
unnamed: R3.1, U3.5
unnamed: Q1.D, R9.1, R10.1
unnamed: Q3.S, U6.12
unnamed: C8.1, LCD1.3, R10.2, R13.2
unnamed: JP1.2, LCD1.2, R9.2
unnamed: Q1.G, R8.1
unnamed: LCD1.16, Q2.D
unnamed: LCD1.15, R11.2
unnamed: C12.2, U7.7, X1.2
unnamed: C11.2, U7.6, X1.1
SPI_MISO: J2.7, U7.27
SPI_MOSI: J2.3, U7.28
SPI_SCK: J2.5, U7.31
SPI_SSEL: J2.2, U7.10
SWCLK: P1.4, U7.29
SWDIO: P1.2, U7.39
TEMP: U7.40, U8.2
UART_RXD: K1.2, U6.1, U7.46
UART_TXD: K1.1, U6.2, U7.47
VBAT: J1.7, SW1.2, W2.1
~RESET: P1.10, U7.3

## KiCad design obd2/obd2.kicad_pcb

Parts:
C1: 0.33uF
C2, C3: 0.1uF
C4, C5: 39pF
C6: 10uF
C7, C8, C9, C10: 0.1u
C11: C
C12, C13: 1u
D1: 3V3_ON
D2: 1N4149
F1: approx 300mA
J1: RJ45_BASIC
J2: MICRO_SD
JP1: LCD_V_SELECT
JP2: K_LINE
JP3: L_LINE
JP4: SCS
K1: UART
LCD1: LCD16X2
LCD2: LCD_COG
MP1, MP2, MP3, MP4: SCREW_4-40
P1: JTAG_PROG
P2: IO_1
P3: IO_2
R1: 330R
R2: R
R3, R4: 60 Ohm
R5: 4k7
R6, R7, R8: 10k
R9: R_LCD_LED
R10: R_CON1
R11: R_CON2
SW1, SW2, SW3: SW_OFF_MOM
SW4: PWR_SW
U1: SP7805
U2: LM335
U3: LD1117
U4: LPC11C14
U5: MCP2561
W1: VBAT_T
W2: 5V_T
W3: 3V3_T
W4: 12V_T
X1: 20MHz

Connections:
+3.3V: C6.1, C7.1, C8.1, C10.1, J2.4 (VDD), JP1.1, LCD2.7 (VDD), P1.1, P3.2, R1.1, R6.1, R7.1, R8.1, R9.1, U3.2 (Vout), U4.8 (VDD), U4.44 (VDD), W3.1
+5V: C2.1, C3.1, C9.1, JP1.3, R5.1, U1.3 (Vout), U3.3 (Vin), U5.3 (VDD), W2.1
+12V: C1.1, F1.1, U1.1 (Vin), W4.1
Button1: R6.2, SW1.2, U4.18 (PIO2_4); also elsewhere on the board
Button2: R7.2, SW2.2, U4.21 (PIO2_5); also elsewhere on the board
Button3: R8.2, SW3.2, U4.24 (PIO2_9); also elsewhere on the board
CAN_H: J1.1, R3.1, U5.7 (CANH)
CAN_L: J1.2, R4.2, U5.6 (CANL)
CAN_RXD: U4.19 (CAN_RXD), U5.4 (RXD)
CAN_TXD: U4.20 (CAN_TXD), U5.1 (TXD)
CAN_XCVR_RS: U4.48 (PIO3_3/RI_N), U5.8 (RS)
CARD_DETECT: J2.12 (SWITCH), U4.25 (PIO2_10)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, D1.2 (K), J1.3, J1.8, J2.6 (GND), J2.9 (CASE_(GND)), J2.10 (CASE_(GND)), J2.11 (DETECT_(GND)), J2.13 (CASE_(GND)), J2.14 (CASE_(GND)), K1.3, LCD1.1 (VSS), LCD1.16 (LED-), LCD2.6 (VSS), LCD2.12 (LED-), P1.3, P1.5, P1.9, P2.4, P3.1, R11.1, SW1.1, SW2.1, SW3.1, U1.2 (GND), U2.1, U3.1 (GND), U4.5 (VSS), U4.41 (VSS), U5.2 (VSS), W1.2, W2.2, W3.2, W4.2; also elsewhere on the board
K_LINE: J1.5, JP2.1
LCD_DB4/SCL: LCD1.11 (DB4), LCD2.2 (RS), U4.36 (PIO3_0/DTR_N)
LCD_DB5/RST: LCD1.12 (DB5), LCD2.1 (RST), U4.37 (PIO3_1/DSR_N)
LCD_DB6: LCD1.13 (DB6), U4.43 (PIO3_2/DCD_N)
LCD_DB7: LCD1.14 (DB7), U4.45 (PIO1_5/RTS_N/CT32B0_CAP0)
LCD_E/CSB: LCD1.6 (E), LCD2.3 (CSB), U4.35 (R/PIO1_2/AD3/CT32B1_MAT1)
LCD_RS/SI: LCD1.4 (RS), LCD2.5 (SI), U4.33 (R/PIO1_0/AD1/CT32B1_CAP0)
LCD_RW/RS: LCD1.5 (RW), LCD2.4 (SCL), U4.34 (R/PIO1_1/AD2/CT32B1_MAT0)
L_LINE: J1.6, JP3.1
unnamed: C4.2, U4.6 (XTALIN), X1.1
unnamed: C5.2, U4.7 (XTALOUT), X1.2, X1.4
unnamed: D2.1 (A), SW4.1
unnamed: JP4.2, P2.3, U4.1 (PIO2_6)
unnamed: JP3.2, P2.2, U4.2 (PIO2_0/DTR_N/SSEL1)
unnamed: JP2.2, P2.1, U4.4 (PIO0_1/CLKOUT/CT32B0_MAT2)
unnamed: P3.3, U4.17 (PIO1_9/CT16B1_MAT0)
unnamed: P3.5, U4.15 (PIO0_4/SCL)
unnamed: P3.4, U4.16 (PIO0_5/SDA)
unnamed: P3.6, U4.14 (PIO0_3)
unnamed: JP1.2, LCD1.2 (VDD), R10.2
unnamed: LCD1.15 (LED+), LCD2.11 (LED+), R9.2
unnamed: C12.2, LCD2.8 (VOUT)
unnamed: C13.2, LCD2.10 (C1-)
unnamed: C13.1, LCD2.9 (C1+)
unnamed: D1.1 (A), R1.2
unnamed: R2.1, U5.5 (SPLIT)
unnamed: C11.2, R2.2, R3.2, R4.1
unnamed: D2.2 (K), F1.2
unnamed: LCD1.3 (V0), R10.1, R11.2
SCS: J1.4, JP4.1
SPI_MISO: J2.7 (DAT0), U4.27 (PIO0_8/MISO0/CT16B0_MAT0)
SPI_MOSI: J2.3 (CMD), U4.28 (PIO0_9/MOSI0/CT16B0_MAT1)
SPI_SCK: J2.5 (CLOCK), U4.31 (PIO2_11/SCK0)
SPI_SSEL: J2.2 (CD/DAT3), U4.10 (PIO0_2/SSEL0/CT16B0_CAP0)
SWCLK: P1.4, U4.29 (SWCLK/PIO0_10/SCK0/CT16B0_MAT2)
SWDIO: P1.2, U4.39 (SWDIO/PIO1_3/AD4/CT32B1_MAT2)
TEMP: R5.2, U2.2, U4.42 (PIO1_11/AD7)
UART_RXD: K1.2 (PM), U4.46 (PIO1_6/RXD/CT32B0_MAT0)
UART_TXD: K1.1, U4.47 (PIO1_7/TXD/CT32B0_MAT1)
VBAT: J1.7, SW4.2, W1.1
~RESET: P1.10, U4.3 (RESET_N/PIO0_0)

Notes on the sheet:
XTAL required if C_CAN baud rates above 100kbit/s used
Mounting holes 4-40 hardware
Option for one of two types of LCD screen
Micro-SD circuitry
CAN transceiver circuitry
Sensor circuitry
OBD2 connection DLC - Diagnostic Link Connector in Honda Civic
User input
1 2 3 4 5 6 7 8 9 10 11 12 13 14 15 16
4 - Chassis Ground 5 - Signal Ground 6 - CAN high (J-2284) 7 - K-LINE (ISO 9141-2 and ISO/DIS 14230-4) 9 - SCS - (Service Check System - diagnostic codes) 14 - CAN low 15 - ISO 9141-2 L-Line (ISO 9141-2 and ISO/DIS 14230-4) 16 - +12V unswitched
R_CON1 and R_CON2 set contrast. R_LCD_LED sets LCD backlight brightness (10-30ohm)
VBAT is unswitched battery voltage +12V is switched/diode/fused +5V/+3.3V are regulated voltages

Board: 2 copper layers, 80.0 x 49.0 mm, 57 parts (12 on the bottom side), 54 nets.

Other parts of the board:
1, 2, 3: SW_OFF_MOM; FSM4JSMA_pushbutton

Their connections:
Button1: 3.2; also elsewhere on the board
Button2: 2.2; also elsewhere on the board
Button3: 1.2; also elsewhere on the board
GND: 1.1, 2.1, 3.1; also elsewhere on the board

## Commit log

2013-11-08 Initial commit.
2013-11-08 Added lpc11cxx usermanual and datasheet
2013-11-08 Added new kicad project for old design with lpc1343
2013-11-14 Moved some files around.
2013-11-14 Added bare-bones firmware
2013-11-26 Added datasheets for many components
2013-11-26 Automotive power protection reference
2013-11-26 Almost done schematic and component selections
2013-12-06 Added datasheets for diode/fuses/power switch
2013-12-06 All signals routed but power
2013-12-14 Routed power and added port for UART. Added logos.
2013-12-16 Added schematic and copper printouts in ps, pdf format
2013-12-31 Moved components to add enough room for 4-40 hardware. Moved all silkscreen values to appropriate places. rev 1 finished and ordered.
2013-12-31 Re-arranged directory structure. Added images to image/ directory. Added doc/ director.
2014-01-23 Rearranged structure. added images.
2014-03-05 Added gitignore, added lpc usermanual, added BOM with comments
2014-05-15 Added errors reference and dictionary reference
2014-05-15 Ignore object and lib files
2014-05-15 Ignore axf, object, and debug files
2014-05-15 Added obd2 and chip library for lpc11cxx
2014-05-15 Added readme
2014-05-15 Ignore axf firmware files
2014-05-15 Change comments to further explain button 1 interrupt CAN message. Change default CAN speed to 250kHz.
2014-07-25 Added can control program. Ignoring reference files, ignoring JPG, added blueterm logs
2014-07-25 Removed reference info
2014-07-25 Removed .mk files, added crc and command interface. Significant update to code.
2014-08-08 Added timer functions
2014-08-08 can control updated
2014-08-08 Added timeout timer and fixed bugs in hdlc
2014-08-08 Fixed makefile to be more general
2014-08-08 Added null character to all sprintfs
2014-08-08 Fixed bug in hdlc
2014-08-08 Added null character to snprintfs
2014-08-08 Removed ld files from repo
2014-08-08 Added ld files to ignore
2014-08-08 REmoved binary
2014-08-08 removed map
2014-08-08 Added map to ignore
2014-08-26 New revision fixing multiple footprint issues, adding bt module, smaller temp sensor and K-line txvr among other things.
2014-08-26 removed unecessary images
